# Keil uVision project Led_7seg.uvproj, settings and files
target Target 1 (MCS-51)
  device: T80C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: Led_7seg +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c hienthi.c
    ../PJ1/: delay.c
